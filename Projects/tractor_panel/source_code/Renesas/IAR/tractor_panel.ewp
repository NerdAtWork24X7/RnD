# IAR project tractor_panel.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F10BBC RL78 - R5F10BBC
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  OBJCOPY.OOCOutputFile: tractor_panel.srec
  ILINK.IlinkOutputFile: tractor_panel.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: G:\Repository\RnD\Projects\tractor_panel\source_code\Renesas\IAR\Linker\lnkr5f10bbc.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: templproj.srec
  group contrib/atomics
    contrib/atomics/src/: 8byte.c bitarray.c bitfield.c read.c write.c
    contrib/atomics/inc/: 8byte.h bitfield.h read.h write.h
  group contrib/cantp
    contrib/cantp/src/: isotp.c receive.c send.c
    contrib/cantp/inc/: isotp.h isotp_types.h receive.h send.h
  group contrib/gen
    contrib/gen/src/: r_cg_cgc.c r_cg_cgc_user.c r_cg_vector_table.c r_cg_wdt.c r_cg_wdt_user.c r_hardware_setup.c r_main.c r_reset_program.asm tractor_panel.c
    contrib/gen/inc/: r_cg_cgc.h r_cg_interrupt_handlers.h r_cg_macrodriver.h r_cg_userdefine.h r_cg_wdt.h
  group contrib/mcal
    contrib/mcal/src/: hwinit.c inthandler.c start.S vects.c
    contrib/mcal/inc/: interrupt_handlers.h iodefine.h iodefine_ext.h typedefine.h
  group contrib/uds
    contrib/uds/src/: extras.c uds.c
    contrib/uds/inc/: extras.h uds.h uds_types.h
